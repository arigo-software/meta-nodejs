require nodejs_8.inc

INC_PR = "r1"

LIC_FILES_CHKSUM = "file://LICENSE;md5=fde91d5c5bbd1e0389623e1ac018d9e8"

SRC_URI[src.md5sum] = "e0fe79fdf48c3e6dff9371ac29d52717"
SRC_URI[src.sha256sum] = "86678028f13b26ceed08efc4b838921ca1bf514c0b7e8151bfec8ba15c5e66ad"
